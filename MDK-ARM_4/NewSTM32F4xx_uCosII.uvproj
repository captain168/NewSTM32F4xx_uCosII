# Keil uVision project NewSTM32F4xx_uCosII.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: NewSTM32F4xx_uCosII
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\uCOS-II\Source;..\uCOS-II\Port;..\uCOS-II\Port\ARM-Cortex-M4;..\StartUp;..\STM32F4xx_StdPeriph_Driver\src;..\CMSIS\ST\STM32F4xx\Include;..\CMSIS\Include;..\Utilities\STM32F4-Discovery;..\STM32F4xx_StdPeriph_Driver\inc;..\App;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: main.c system_stm32f4xx.c
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_it.c
  group StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uCos-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCos-II/Port
    ../uCOS-II/Port/ARM-Cortex-M4/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group BSP
    ../BSP/: bsp.c
  group StartupCode
    ../StartUp/: startup_stm32f4xx.s
  group CMSIS
    ../CMSIS/ST/STM32F4xx/Include/: stm32f4xx.h
  group Utilities
    ../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
